#pragma once

#include <cstdint>

#include "Icon.h"

// Simplified, front-facing static sprites for Wappo on e-ink (no directional animations).
namespace wappo {

static constexpr uint8_t icon_player_32_bits[] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
    0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x86, 0x61, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x99,
    0x99, 0xFF, 0xFF, 0x99, 0x99, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x9C, 0x39, 0xFF, 0xFF, 0xDE, 0x7B, 0xFF, 0xFF,
    0xCF, 0xF3, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
    0xFE, 0x30, 0x0C, 0x7F, 0xFE, 0x70, 0x0E, 0x7F, 0xFE, 0x70, 0x0E, 0x7F, 0xFE, 0x70, 0x0E, 0x7F, 0xFF, 0xF0, 0x0F,
    0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF1, 0x8F, 0xFF, 0xFF, 0xF1, 0x8F, 0xFF, 0xFF, 0xE1,
    0x87, 0xFF, 0xFF, 0xC1, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};
static const freeink::Icon icon_player_32 = {32, 32, 16, icon_player_32_bits};

static constexpr uint8_t icon_yel_32_bits[] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x8F, 0xF1,
    0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x0E,
    0x70, 0x3F, 0xFC, 0x1A, 0x58, 0x3F, 0xFC, 0x1A, 0x58, 0x3F, 0xFC, 0x0E, 0x70, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
    0x00, 0x00, 0x3F, 0xFC, 0x60, 0x06, 0x3F, 0xFC, 0x6A, 0xB6, 0x3F, 0xFC, 0x60, 0x06, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
    0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
    0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0xFF, 0x87,
    0xE1, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};
static const freeink::Icon icon_yel_32 = {32, 32, 16, icon_yel_32_bits};

static constexpr uint8_t icon_red_32_bits[] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xC1, 0xFF, 0xFF, 0x83, 0x81, 0xFF, 0xFF, 0x81, 0xC0, 0xE0, 0x07,
    0x03, 0xE0, 0x40, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
    0x00, 0x07, 0xE0, 0xC1, 0x83, 0x07, 0xE1, 0xC3, 0xC3, 0x87, 0xE1, 0x67, 0xE5, 0x87, 0xE1, 0x67, 0xE5, 0x87, 0xE1,
    0xC3, 0xC3, 0x87, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0x80, 0x01, 0xC7, 0xE6, 0xAA, 0xAA, 0xE7, 0xE6, 0xFF, 0xFE, 0xE7,
    0xE6, 0xAA, 0xAA, 0xE7, 0xE3, 0x80, 0x01, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
    0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F,
    0xF0, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};
static const freeink::Icon icon_red_32 = {32, 32, 16, icon_red_32_bits};

static constexpr uint8_t icon_pit_32_bits[] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
    0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
    0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC6, 0xAA, 0xAA, 0xA3, 0xCA, 0xAA, 0xAA, 0xA3, 0xCD,
    0x55, 0x55, 0x53, 0xCA, 0xAA, 0xAA, 0xA3, 0xCD, 0x55, 0x55, 0x53, 0xCA, 0xAA, 0xAA, 0xA3, 0xCD, 0x55, 0x55, 0x53,
    0xCA, 0xAA, 0xAA, 0xA3, 0xC6, 0xAA, 0xAA, 0xA3, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
    0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
    0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};
static const freeink::Icon icon_pit_32 = {32, 32, 16, icon_pit_32_bits};

// White laid under a piece before its ink, so it reads as a solid figure on the
// dithered floor: the sprite's filled shape -- its ink plus every transparent
// pixel the outside cannot reach (face, eyes, body) -- grown kHaloPx all round.
// Derived from the sprite at compile time, so the two cannot drift apart.
// Same convention as the sprites: bit 0 = paint.
constexpr int kHaloPx = 2;

struct Mask32 {
  uint8_t bits[128];
};

constexpr Mask32 haloOf(const uint8_t* sprite, const int grow) {
  // One uint32_t per row, bit 31 = column 0, set = ink.
  uint32_t ink[32] = {};
  for (int y = 0; y < 32; ++y) {
    uint32_t row = 0;
    for (int b = 0; b < 4; ++b) row = (row << 8) | static_cast<uint8_t>(~sprite[y * 4 + b]);
    ink[y] = row;
  }

  // Flood the transparent pixels that can be reached from the edge.
  uint32_t outside[32] = {};
  for (int y = 0; y < 32; ++y) outside[y] = (y == 0 || y == 31) ? ~ink[y] : ~ink[y] & 0x80000001u;
  for (bool grew = true; grew;) {
    grew = false;
    for (int y = 0; y < 32; ++y) {
      uint32_t reach = outside[y] | (outside[y] << 1) | (outside[y] >> 1);
      if (y > 0) reach |= outside[y - 1];
      if (y < 31) reach |= outside[y + 1];
      reach &= ~ink[y];
      if (reach != outside[y]) {
        outside[y] = reach;
        grew = true;
      }
    }
  }

  uint32_t fill[32] = {};
  for (int y = 0; y < 32; ++y) fill[y] = ~outside[y];
  for (int g = 0; g < grow; ++g) {
    uint32_t next[32] = {};
    for (int y = 0; y < 32; ++y) {
      next[y] = fill[y] | (fill[y] << 1) | (fill[y] >> 1);
      if (y > 0) next[y] |= fill[y - 1];
      if (y < 31) next[y] |= fill[y + 1];
    }
    for (int y = 0; y < 32; ++y) fill[y] = next[y];
  }

  Mask32 out{};
  for (int y = 0; y < 32; ++y) {
    for (int b = 0; b < 4; ++b) out.bits[y * 4 + b] = static_cast<uint8_t>(~(fill[y] >> (24 - 8 * b)));
  }
  return out;
}

static constexpr Mask32 halo_player_32_bits = haloOf(icon_player_32_bits, kHaloPx);
static constexpr Mask32 halo_yel_32_bits = haloOf(icon_yel_32_bits, kHaloPx);
static constexpr Mask32 halo_red_32_bits = haloOf(icon_red_32_bits, kHaloPx);
static constexpr Mask32 halo_pit_32_bits = haloOf(icon_pit_32_bits, kHaloPx);
static const freeink::Icon halo_player_32 = {32, 32, 16, halo_player_32_bits.bits};
static const freeink::Icon halo_yel_32 = {32, 32, 16, halo_yel_32_bits.bits};
static const freeink::Icon halo_red_32 = {32, 32, 16, halo_red_32_bits.bits};
static const freeink::Icon halo_pit_32 = {32, 32, 16, halo_pit_32_bits.bits};

}  // namespace wappo
